# Keil uVision project STM32Project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32Project
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STARTUP;..\USER;..\BSP\inc;..\FWLIB\inc;..\ALGORITHM\inc;..\HARDWARE\inc;..\CHISHI
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CORE
    ../CORE/: core_cm3.c
  group USER
    ./: main.c system_stm32f10x.c sys.c moto_demo.c
    ../CHISHI/: task.c gui.c transmit.c
  group STARTUP
    ../STARTUP/: startup_stm32f10x_hd.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_it.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ../HARDWARE/: drv_can.c drv_systick.c drv_timer.c drv_uart.c drv_usart.c drv_adc.c drv_gpio.c drv_pwm.c
  group BSP
    ../BSP/: bsp_robomodule.c bsp_esc.c bsp_key.c bsp_led.c bsp_oled.c
  group ARITHMETIC
    ../ALGORITHM/: chassis.c moto_control.c pid.c user_math.c wave_filter.c
